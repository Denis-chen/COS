# Keil uVision project ACH512.uvproj, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ACH512 +hex
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1
  c include: .\ACH512\driver;.\ACH512\system;.\APP;.\CMSIS\Include;.\COMMON
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000040 size 0x1ffc0
  group system
    ./ACH512/system/: startup.s system_ach512.c
  group driver
    ./ACH512/driver/: uart.c hrng_20171106.lib ecdsa_20171106.lib pki_20170406.lib rsa_20171106.lib sha1_20171106.lib sha256_20171106.lib sha384_20171106.lib sm3_20171106.lib
  group common
    ./COMMON/: common.c
  group app
    ./APP/: app.c main.c blake2b.c blake2s.c hmac_sha2.c sha2.c bip32.c hmac.c internal.c ripemd160.c secp256k1.c sign.c hex.c pbkdf2.c bip39.c
  group doc
    ./: Abstratct.txt
